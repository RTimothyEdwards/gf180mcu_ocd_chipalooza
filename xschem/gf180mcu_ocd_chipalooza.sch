v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Chipalooza GF harness chip top level
Padframe + core} -753.1365441411585 -1670 0 0 0.4 0.4 {}
N -870 -1060 -790 -1060 {lab=gpio_in[11:0]}
N -870 -1040 -790 -1040 {lab=CSB_in}
N -870 -1020 -790 -1020 {lab=SDI_in}
N -870 -1000 -790 -1000 {lab=SCK_in}
N -870 -980 -790 -980 {lab=clk_in}
N -60 -160 -20 -160 {lab=SDO}
N -60 -180 -20 -180 {lab=SDI}
N -60 -200 -20 -200 {lab=CSB}
N -60 -220 -20 -220 {lab=SCK}
N -60 -240 -20 -240 {lab=clk}
N -60 -140 -20 -140 {lab=analog[3:0]}
N -60 -120 -20 -120 {lab=gpio[11:0]}
N -60 -100 -20 -100 {lab=vddd}
N -60 -80 -20 -80 {lab=vss5v0}
N -60 -60 -20 -60 {lab=vdd5v0}
N -60 -40 -20 -40 {lab=vss3v3}
N -60 -20 -20 -20 {lab=vdd3v3}
N -60 -660 -20 -660 {lab=gpio_ie[11:0]}
N -60 -680 -20 -680 {lab=gpio_slew[11:0]}
N -60 -720 -20 -720 {lab=gpio_pullup[11:0]}
N -60 -640 -20 -640 {lab=gpio_oe[11:0]}
N 250 -160 290 -160 {lab=SDI_zero}
N 250 -140 290 -140 {lab=SDI_in}
N 250 -120 290 -120 {lab=#net1}
N 250 -100 290 -100 {lab=SDO_zero}
N 250 -80 290 -80 {lab=#net2}
N 250 -60 290 -60 {lab=#net3}
N 250 -40 290 -40 {lab=#net4}
N 250 -20 290 -20 {lab=gpio_in[11:0]}
N -490 -840 -450 -840 {lab=vddd}
N -490 -960 -450 -960 {lab=vdd5v0}
N -490 -940 -450 -940 {lab=vss5v0}
N -490 -900 -450 -900 {lab=vdd3v3}
N -490 -860 -450 -860 {lab=vss3v3}
N -490 -820 -450 -820 {lab=gpio_out[11:0]}
N -490 -800 -450 -800 {lab=gpio_oe[11:0]}
N -490 -620 -450 -620 {lab=s9_an[0:2]}
N -490 -780 -450 -780 {lab=gpio_ie[11:0]}
N -490 -760 -450 -760 {lab=gpio_schmitt[11:0]}
N -490 -740 -450 -740 {lab=gpio_slew[11:0]}
N -490 -720 -450 -720 {lab=gpio_pullup[11:0]}
N -490 -700 -450 -700 {lab=gpio_pulldown[11:0]}
N -490 -680 -450 -680 {lab=analog[3:0]}
N -490 -660 -450 -660 {lab=sdo_ena}
N -490 -640 -450 -640 {lab=sdo_out}
N -490 -600 -450 -600 {lab=s10_an[0:2]}
N -490 -540 -450 -540 {lab=s8_an[0]}
N -490 -360 -450 -360 {lab=s15_an[0]}
N -490 -520 -450 -520 {lab=s11_an[0]}
N -490 -500 -450 -500 {lab=s7_an[0:1]}
N -490 -480 -450 -480 {lab=s12_an[0:1]}
N -490 -460 -450 -460 {lab=s6_an[0:1]}
N -490 -440 -450 -440 {lab=s13_an[0:1]}
N -490 -420 -450 -420 {lab=s5_an[0:1]}
N -490 -400 -450 -400 {lab=s14_an[0:1]}
N -490 -380 -450 -380 {lab=s4_an[0:1]}
N -490 -340 -450 -340 {lab=s3_an[0:1]}
N -490 -320 -450 -320 {lab=s16_an[0:1]}
N -490 -300 -450 -300 {lab=vss3v3}
N -490 -280 -450 -280 {lab=vss5v0}
N -490 -260 -450 -260 {lab=s2_an[0:1]}
N -490 -240 -450 -240 {lab=s17_an[0:1]}
N -60 -700 -20 -700 {lab=gpio_schmitt[11:0]}
N -60 -620 -20 -620 {lab=gpio_out[11:0]}
N -60 -400 -20 -400 {lab=s8_an[0]}
N -60 -420 -20 -420 {lab=s9_an[2:0]}
N -60 -440 -20 -440 {lab=s10_an[2:0]}
N -60 -460 -20 -460 {lab=s11_an[0]}
N -60 -480 -20 -480 {lab=s12_an[1:0]}
N -60 -380 -20 -380 {lab=s7_an[1:0]}
N -60 -360 -20 -360 {lab=s6_an[1:0]}
N -60 -340 -20 -340 {lab=s5_an[1:0]}
N -60 -320 -20 -320 {lab=s4_an[1:0]}
N -60 -300 -20 -300 {lab=s3_an[1:0]}
N -60 -280 -20 -280 {lab=s2_an[1:0]}
N -60 -260 -20 -260 {lab=s1_an[1:0]}
N -60 -600 -20 -600 {lab=s18_an[1:0]}
N -60 -580 -20 -580 {lab=s17_an[1:0]}
N -60 -560 -20 -560 {lab=s16_an[1:0]}
N -60 -540 -20 -540 {lab=s15_an[1:0]}
N -60 -520 -20 -520 {lab=s14_an[1:0]}
N -60 -500 -20 -500 {lab=s13_an[1:0]}
N -870 -1080 -790 -1080 {lab=CSB_one}
N -870 -1100 -790 -1100 {lab=CSB_zero}
N -870 -1120 -790 -1120 {lab=SCK_zero}
N -870 -1140 -790 -1140 {lab=SDI_zero}
N -870 -1160 -790 -1160 {lab=clk_zero}
N -870 -1180 -790 -1180 {lab=SDO_zero}
N -490 -880 -450 -880 {lab=CSB_pulldown}
N -490 -920 -450 -920 {lab=CSB_pullup}
N -490 -980 -450 -980 {lab=SCK_pulldown}
N -490 -1000 -450 -1000 {lab=SCK_pullup}
N -490 -1020 -450 -1020 {lab=SDI_pulldown}
N -490 -1040 -450 -1040 {lab=SDI_pullup}
N -490 -1060 -450 -1060 {lab=clk_pulldown}
N -490 -1080 -450 -1080 {lab=clk_pullup}
N -490 -1100 -450 -1100 {lab=SDO_pulldown}
N -490 -1120 -450 -1120 {lab=SDO_pullup}
N -490 -1140 -450 -1140 {lab=SDO_slew}
N -490 -1160 -450 -1160 {lab=SDO_schmitt}
N -490 -1180 -450 -1180 {lab=SDO_ie}
N -60 -740 -20 -740 {lab=gpio_pulldown[11:0]}
N -60 -760 -20 -760 {lab=sdo_out}
N -60 -780 -20 -780 {lab=sdo_ena}
N -60 -800 -20 -800 {lab=SDO_ie}
N -60 -820 -20 -820 {lab=SDO_slew}
N -60 -840 -20 -840 {lab=SDO_schmitt}
N -60 -860 -20 -860 {lab=SDO_pullup}
N -60 -880 -20 -880 {lab=SDO_pulldown}
N -60 -900 -20 -900 {lab=SDI_pullup}
N -60 -920 -20 -920 {lab=SDI_pulldown}
N -60 -940 -20 -940 {lab=CSB_pullup}
N -60 -960 -20 -960 {lab=CSB_pulldown}
N 250 -180 290 -180 {lab=#net5}
N 250 -200 290 -200 {lab=CSB_in}
N 250 -220 290 -220 {lab=CSB_zero}
N 250 -240 290 -240 {lab=CSB_one}
N 250 -260 290 -260 {lab=SCK_in}
N 250 -280 290 -280 {lab=SCK_zero}
N 250 -300 290 -300 {lab=#net6}
N 250 -320 290 -320 {lab=clk_in}
N 250 -340 290 -340 {lab=clk_zero}
N 250 -360 290 -360 {lab=#net7}
N -60 -1020 -20 -1020 {lab=clk_pullup}
N -60 -1040 -20 -1040 {lab=clk_pulldown}
N -60 -1000 -20 -1000 {lab=SCK_pulldown}
N -60 -980 -20 -980 {lab=SCK_pullup}
N -490 -220 -450 -220 {lab=s1_an[0:1]}
N -490 -200 -450 -200 {lab=s18_an[0:1]}
N -490 -580 -450 -580 {lab=vss3v3}
N -490 -560 -450 -560 {lab=vss5v0}
N -490 -180 -450 -180 {lab=#net8}
N -490 -160 -450 -160 {lab=#net9}
N -490 -140 -450 -140 {lab=vss3v3}
N -490 -120 -450 -120 {lab=vss3v3}
C {gf180mcu_padframe.sym} 0 0 0 0 {name=x1}
C {chipalooza_frame.sym} -640 -650 0 0 {name=x2}
C {lab_pin.sym} -870 -1060 0 0 {name=p6 sig_type=std_logic lab=gpio_in[11:0]}
C {lab_pin.sym} -450 -660 0 1 {name=p7 sig_type=std_logic lab=sdo_ena}
C {iopin.sym} -60 -160 0 1 {name=p8 lab=SDO}
C {lab_pin.sym} -450 -820 0 1 {name=p14 sig_type=std_logic lab=gpio_out[11:0]}
C {lab_pin.sym} -450 -800 0 1 {name=p15 sig_type=std_logic lab=gpio_oe[11:0]}
C {iopin.sym} -60 -140 0 1 {name=p16 lab=analog[3:0]}
C {iopin.sym} -60 -120 0 1 {name=p18 lab=gpio[11:0]}
C {iopin.sym} -60 -60 0 1 {name=p17 lab=vdd5v0}
C {iopin.sym} -60 -80 0 1 {name=p19 lab=vss5v0}
C {iopin.sym} -60 -20 0 1 {name=p20 lab=vdd3v3}
C {iopin.sym} -60 -40 0 1 {name=p21 lab=vss3v3}
C {iopin.sym} -60 -100 0 1 {name=p22 lab=vddd}
C {ipin.sym} -60 -180 0 0 {name=p23 lab=SDI}
C {ipin.sym} -60 -220 0 0 {name=p24 lab=SCK}
C {ipin.sym} -60 -240 0 0 {name=p25 lab=clk}
C {ipin.sym} -60 -200 0 0 {name=p26 lab=CSB}
C {lab_pin.sym} -870 -1040 0 0 {name=p1 sig_type=std_logic lab=CSB_in}
C {lab_pin.sym} -870 -1020 0 0 {name=p2 sig_type=std_logic lab=SDI_in}
C {lab_pin.sym} -870 -1000 0 0 {name=p3 sig_type=std_logic lab=SCK_in}
C {lab_pin.sym} -870 -980 0 0 {name=p4 sig_type=std_logic lab=clk_in}
C {lab_pin.sym} 290 -20 0 1 {name=p10 sig_type=std_logic lab=gpio_in[11:0]}
C {lab_pin.sym} 290 -200 0 1 {name=p11 sig_type=std_logic lab=CSB_in}
C {lab_pin.sym} 290 -140 0 1 {name=p12 sig_type=std_logic lab=SDI_in}
C {lab_pin.sym} 290 -260 0 1 {name=p13 sig_type=std_logic lab=SCK_in}
C {lab_pin.sym} 290 -320 0 1 {name=p27 sig_type=std_logic lab=clk_in}
C {lab_pin.sym} -60 -620 0 0 {name=p39 sig_type=std_logic lab=gpio_out[11:0]}
C {lab_pin.sym} -60 -640 0 0 {name=p40 sig_type=std_logic lab=gpio_oe[11:0]}
C {lab_pin.sym} -60 -780 0 0 {name=p41 sig_type=std_logic lab=sdo_ena}
C {lab_pin.sym} -60 -760 0 0 {name=p64 sig_type=std_logic lab=sdo_out}
C {lab_pin.sym} -450 -640 0 1 {name=p65 sig_type=std_logic lab=sdo_out}
C {lab_pin.sym} -450 -680 0 1 {name=p67 sig_type=std_logic lab=analog[3:0]}
C {lab_pin.sym} -450 -960 0 1 {name=p72 sig_type=std_logic lab=vdd5v0}
C {lab_pin.sym} -450 -940 0 1 {name=p73 sig_type=std_logic lab=vss5v0}
C {lab_pin.sym} -450 -900 0 1 {name=p74 sig_type=std_logic lab=vdd3v3}
C {lab_pin.sym} -450 -860 0 1 {name=p75 sig_type=std_logic lab=vss3v3}
C {lab_pin.sym} -450 -840 0 1 {name=p76 sig_type=std_logic lab=vddd}
C {lab_pin.sym} -450 -620 0 1 {name=p77 sig_type=std_logic lab=s9_an[0:2]}
C {lab_pin.sym} -450 -600 0 1 {name=p78 sig_type=std_logic lab=s10_an[0:2]}
C {lab_pin.sym} -450 -500 0 1 {name=p79 sig_type=std_logic lab=s7_an[0:1]}
C {lab_pin.sym} -450 -480 0 1 {name=p80 sig_type=std_logic lab=s12_an[0:1]}
C {lab_pin.sym} -450 -460 0 1 {name=p81 sig_type=std_logic lab=s6_an[0:1]}
C {lab_pin.sym} -450 -440 0 1 {name=p82 sig_type=std_logic lab=s13_an[0:1]}
C {lab_pin.sym} -450 -420 0 1 {name=p83 sig_type=std_logic lab=s5_an[0:1]}
C {lab_pin.sym} -450 -400 0 1 {name=p84 sig_type=std_logic lab=s14_an[0:1]}
C {lab_pin.sym} -450 -340 0 1 {name=p85 sig_type=std_logic lab=s3_an[0:1]}
C {lab_pin.sym} -450 -320 0 1 {name=p86 sig_type=std_logic lab=s16_an[0:1]}
C {lab_pin.sym} -450 -260 0 1 {name=p87 sig_type=std_logic lab=s2_an[0:1]}
C {lab_pin.sym} -450 -240 0 1 {name=p88 sig_type=std_logic lab=s17_an[0:1]}
C {lab_pin.sym} -450 -220 0 1 {name=p89 sig_type=std_logic lab=s1_an[0:1]}
C {lab_pin.sym} -450 -200 0 1 {name=p90 sig_type=std_logic lab=s18_an[0:1]}
C {lab_pin.sym} -450 -360 0 1 {name=p91 sig_type=std_logic lab=s15_an[0]}
C {lab_pin.sym} -450 -380 0 1 {name=p92 sig_type=std_logic lab=s4_an[0:1]}
C {lab_pin.sym} -450 -520 0 1 {name=p93 sig_type=std_logic lab=s11_an[0]}
C {lab_pin.sym} -450 -540 0 1 {name=p94 sig_type=std_logic lab=s8_an[0]}
C {iopin.sym} -60 -600 0 1 {name=p185 lab=s18_an[1:0]}
C {iopin.sym} -60 -580 0 1 {name=p108 lab=s17_an[1:0]}
C {iopin.sym} -60 -560 0 1 {name=p95 lab=s16_an[1:0]}
C {iopin.sym} -60 -540 0 1 {name=p96 lab=s15_an[1:0]}
C {iopin.sym} -60 -520 0 1 {name=p97 lab=s14_an[1:0]}
C {iopin.sym} -60 -500 0 1 {name=p98 lab=s13_an[1:0]}
C {iopin.sym} -60 -480 0 1 {name=p99 lab=s12_an[1:0]}
C {iopin.sym} -60 -460 0 1 {name=p100 lab=s11_an[0]}
C {iopin.sym} -60 -440 0 1 {name=p101 lab=s10_an[2:0]}
C {iopin.sym} -60 -420 0 1 {name=p102 lab=s9_an[2:0]}
C {iopin.sym} -60 -400 0 1 {name=p103 lab=s8_an[0]}
C {iopin.sym} -60 -380 0 1 {name=p104 lab=s7_an[1:0]}
C {iopin.sym} -60 -360 0 1 {name=p105 lab=s6_an[1:0]}
C {iopin.sym} -60 -340 0 1 {name=p106 lab=s5_an[1:0]}
C {iopin.sym} -60 -320 0 1 {name=p107 lab=s4_an[1:0]}
C {iopin.sym} -60 -300 0 1 {name=p109 lab=s3_an[1:0]}
C {iopin.sym} -60 -280 0 1 {name=p110 lab=s2_an[1:0]}
C {iopin.sym} -60 -260 0 1 {name=p111 lab=s1_an[1:0]}
C {lab_pin.sym} -450 -780 0 1 {name=p5 sig_type=std_logic lab=gpio_ie[11:0]}
C {lab_pin.sym} -450 -760 0 1 {name=p66 sig_type=std_logic lab=gpio_schmitt[11:0]}
C {lab_pin.sym} -450 -740 0 1 {name=p143 sig_type=std_logic lab=gpio_slew[11:0]}
C {lab_pin.sym} -450 -720 0 1 {name=p144 sig_type=std_logic lab=gpio_pullup[11:0]}
C {lab_pin.sym} -450 -700 0 1 {name=p151 sig_type=std_logic lab=gpio_pulldown[11:0]}
C {lab_pin.sym} -60 -660 0 0 {name=p43 sig_type=std_logic lab=gpio_ie[11:0]}
C {lab_pin.sym} -60 -680 0 0 {name=p44 sig_type=std_logic lab=gpio_slew[11:0]}
C {lab_pin.sym} -60 -700 0 0 {name=p45 sig_type=std_logic lab=gpio_schmitt[11:0]}
C {lab_pin.sym} -60 -720 0 0 {name=p46 sig_type=std_logic lab=gpio_pullup[11:0]}
C {lab_pin.sym} -60 -740 0 0 {name=p47 sig_type=std_logic lab=gpio_pulldown[11:0]}
C {lab_pin.sym} -870 -1080 0 0 {name=p112 sig_type=std_logic lab=CSB_one}
C {lab_pin.sym} -870 -1100 0 0 {name=p114 sig_type=std_logic lab=CSB_zero}
C {lab_pin.sym} -870 -1120 0 0 {name=p115 sig_type=std_logic lab=SCK_zero}
C {lab_pin.sym} -870 -1140 0 0 {name=p116 sig_type=std_logic lab=SDI_zero}
C {lab_pin.sym} -870 -1160 0 0 {name=p117 sig_type=std_logic lab=clk_zero}
C {lab_pin.sym} -870 -1180 0 0 {name=p118 sig_type=std_logic lab=SDO_zero}
C {lab_pin.sym} -450 -880 0 1 {name=p119 sig_type=std_logic lab=CSB_pulldown}
C {lab_pin.sym} -450 -920 0 1 {name=p120 sig_type=std_logic lab=CSB_pullup}
C {lab_pin.sym} -450 -980 0 1 {name=p121 sig_type=std_logic lab=SCK_pulldown}
C {lab_pin.sym} -450 -1000 0 1 {name=p122 sig_type=std_logic lab=SCK_pullup}
C {lab_pin.sym} -450 -1020 0 1 {name=p123 sig_type=std_logic lab=SDI_pulldown}
C {lab_pin.sym} -450 -1040 0 1 {name=p124 sig_type=std_logic lab=SDI_pullup}
C {lab_pin.sym} -450 -1060 0 1 {name=p125 sig_type=std_logic lab=clk_pulldown}
C {lab_pin.sym} -450 -1080 0 1 {name=p126 sig_type=std_logic lab=clk_pullup}
C {lab_pin.sym} -450 -1100 0 1 {name=p127 sig_type=std_logic lab=SDO_pulldown}
C {lab_pin.sym} -450 -1120 0 1 {name=p128 sig_type=std_logic lab=SDO_pullup}
C {lab_pin.sym} -450 -1140 0 1 {name=p129 sig_type=std_logic lab=SDO_slew}
C {lab_pin.sym} -450 -1160 0 1 {name=p130 sig_type=std_logic lab=SDO_schmitt}
C {lab_pin.sym} -450 -1180 0 1 {name=p131 sig_type=std_logic lab=SDO_ie}
C {noconn.sym} 290 -40 0 1 {name=l1[11:0]}
C {noconn.sym} 290 -60 0 1 {name=l2[11:0]}
C {noconn.sym} 290 -360 0 1 {name=l3}
C {noconn.sym} 290 -300 0 1 {name=l1}
C {noconn.sym} 290 -180 0 1 {name=l2}
C {noconn.sym} 290 -120 0 1 {name=l4}
C {lab_pin.sym} 290 -240 0 1 {name=p28 sig_type=std_logic lab=CSB_one}
C {lab_pin.sym} 290 -220 0 1 {name=p29 sig_type=std_logic lab=CSB_zero}
C {lab_pin.sym} 290 -280 0 1 {name=p31 sig_type=std_logic lab=SCK_zero}
C {lab_pin.sym} 290 -340 0 1 {name=p30 sig_type=std_logic lab=clk_zero}
C {lab_pin.sym} 290 -160 0 1 {name=p32 sig_type=std_logic lab=SDI_zero}
C {lab_pin.sym} 290 -100 0 1 {name=p33 sig_type=std_logic lab=SDO_zero}
C {noconn.sym} 290 -80 0 1 {name=l5}
C {lab_pin.sym} -60 -960 0 0 {name=p9 sig_type=std_logic lab=CSB_pulldown}
C {lab_pin.sym} -60 -940 0 0 {name=p34 sig_type=std_logic lab=CSB_pullup}
C {lab_pin.sym} -60 -1000 0 0 {name=p35 sig_type=std_logic lab=SCK_pulldown}
C {lab_pin.sym} -60 -980 0 0 {name=p36 sig_type=std_logic lab=SCK_pullup}
C {lab_pin.sym} -60 -920 0 0 {name=p37 sig_type=std_logic lab=SDI_pulldown}
C {lab_pin.sym} -60 -900 0 0 {name=p38 sig_type=std_logic lab=SDI_pullup}
C {lab_pin.sym} -60 -1040 0 0 {name=p42 sig_type=std_logic lab=clk_pulldown}
C {lab_pin.sym} -60 -1020 0 0 {name=p48 sig_type=std_logic lab=clk_pullup}
C {lab_pin.sym} -60 -880 0 0 {name=p49 sig_type=std_logic lab=SDO_pulldown}
C {lab_pin.sym} -60 -860 0 0 {name=p50 sig_type=std_logic lab=SDO_pullup}
C {lab_pin.sym} -60 -820 0 0 {name=p51 sig_type=std_logic lab=SDO_slew}
C {lab_pin.sym} -60 -840 0 0 {name=p52 sig_type=std_logic lab=SDO_schmitt}
C {lab_pin.sym} -60 -800 0 0 {name=p53 sig_type=std_logic lab=SDO_ie}
C {lab_pin.sym} -450 -580 0 1 {name=p54 sig_type=std_logic lab=vss3v3}
C {lab_pin.sym} -450 -560 0 1 {name=p55 sig_type=std_logic lab=vss5v0}
C {lab_pin.sym} -450 -300 0 1 {name=p56 sig_type=std_logic lab=vss3v3}
C {lab_pin.sym} -450 -280 0 1 {name=p57 sig_type=std_logic lab=vss5v0}
C {lab_pin.sym} -450 -140 0 1 {name=p60 sig_type=std_logic lab=vss3v3}
C {lab_pin.sym} -450 -120 0 1 {name=p61 sig_type=std_logic lab=vss3v3}
C {lab_pin.sym} -450 -180 0 1 {name=p58 sig_type=std_logic lab=vss5v0}
C {lab_pin.sym} -450 -160 0 1 {name=p59 sig_type=std_logic lab=vss5v0}
